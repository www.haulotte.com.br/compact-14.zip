Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2020-06-13T13:33:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Jun 13 13:33:18 2020 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{E1D0D690-7A7A-497C-A160-20795B8FEBC5}\ifc * Database version: 5507 * Database creation date: Sat Jun 13 13:33:09 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Jun 13 13:33:10 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Jun 13 13:33:10 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no; Variantes: Modèle de base
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: Compact 14, Construction_Aerial-Equipment_Haulotte_Compact-14_FR:Compact 14:1394871
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Working_Area, Metal - Haulotte - Black, Metal - Haulotte - Yellow, Red, Metal - Haulotte - Grey Dark, Metal - Haulotte - White, Metal - Haulotte - Grey
Type - Autre(Type) - Catégorie: Equipement spécialisé; Batteries: 4x24V- 271 Ah; Capacité Réservoir Huile Hydraulique: 27 l / 7.13 gal; Nom de la famille: Construction_Aerial-Equipment_Haulotte_Compact-14_FR
Type - Données d'identification(Type) - Code d'assemblage: E10; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: Compact 14; Nom du type: Compact 14; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/compact-14; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte.fr
Type - Données(Type) - Capacité Maximum – Extérieur: 150 kg /330 lb; Capacité Maximum - Intérieur: 350 kg / 771.62 lb; Devers: ±2°; Empattement: 1860 mm/ 73.23 in; Garde au Sol: 70 mm / 2,76 in; Garde au Sol - Potholes Baissés: 15 mm / 0,59 in; Hauteur Maximale de Translation: 11800 mm/ 464.57 in; Hauteur Plateforme: 11800 mm/ 464.57 in; Hauteur Repliée: 2505 mm/ 98.62 in; Hauteur Travail: 13800 mm/543.31 in; Largeur Hors Tout: 1200 mm/ 47.24 in; Largeur Plateforme: 1206 mm/ 47.48 in; Longueur Extension: 920 mm/ 36.22 in; Longueur Hors Tout: 2475 mm/ 7.44 in; Longueur Plateforme: 2310 mm/ 90.94 in; Longueur Plateforme Étendue: 3230 mm/ 127.17 in; Masse Machine (CE): 3200 kg/ 7054.79 lb; Pente Maximum: 23%; Pneus: 378x125x323mm/14.88x4.92x12.72 in; Pression Max au Sol: 28.7 daN/cm2; Rayon de Braquage Exterieur: 2500 mm/ 98.43 in; Rayon de Braquage Interieur: 320 mm / 12.60 in; Vitesse de Translation: 0.85-2.8 km/h / 0.53-1.74 mph
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: Construction_Aerial-Equipment_Haulotte_Compact-14_FR:Compact 14
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_Compact-14_FR: Compact 14; Famille et type: Construction_Aerial-Equipment_Haulotte_Compact-14_FR: Compact 14; H CTRL: 11.138 m; ID du type: Construction_Aerial-Equipment_Haulotte_Compact-14_FR: Compact 14; L: 1.08468 m; Type: Construction_Aerial-Equipment_Haulotte_Compact-14_FR: Compact 14
Construction - Abaque de Travail: yes; Extension Plateforme: 1.17 m; Hauteur de Plateforme: 11.8 m; Rayon de Braquage Exterieur: yes; Zone de Travail: yes
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 68.8441 m2; Volume: 25.2819 m3
Données d'identification - Variantes: Variante 1 : COMPACT
Graphismes - Marque: yes
Phase de construction - Phase de création: Nouvelle construction
